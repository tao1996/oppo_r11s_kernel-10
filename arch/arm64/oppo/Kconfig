## arch/arm64/oppo/Kconfig
```kconfig
menu "OPPO product selection"

config PRODUCT_OPPO
	bool "OPPO devices"
	help
	  This enables support for oppo devices.

endmenu
```
